# Keil uVision project project.uvprojx, settings and files
target rt-thread_stm32f7xx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.10.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_HAL_DRIVER, STM32F769xx, RT_USING_ARM_LIBC
  c include: applications;.;drivers;Libraries\CMSIS\Device\ST\STM32F7xx\Include;Libraries\CMSIS\Include;Libraries\STM32F7xx_HAL_Driver\Inc;..\rt-thread\include;..\rt-thread\libcpu\arm\cortex-m7;..\rt-thread\libcpu\arm\common;..\rt-thread\components\dfs\include;..\rt-thread\components\dfs\filesystems\devfs;..\rt-thread\components\drivers\include;..\rt-thread\components\drivers\include;..\rt-thread\components\drivers\include;..\rt-thread\components\drivers\usb\usbdevice;..\rt-thread\components\finsh;..\rt-thread\components\libc\compilers\armlibc;..\rt-thread\components\libc\compilers\common;..\rt-thread\components\net\lwip-2.0.2\src;..\rt-thread\components\net\lwip-2.0.2\src\include;..\rt-thread\components\net\lwip-2.0.2\src\include\ipv4;..\rt-thread\components\net\lwip-2.0.2\src\arch\include;..\rt-thread\components\net\lwip-2.0.2\src\include\netif;..\rt-thread\components\net\sal_socket\include;..\rt-thread\components\net\sal_socket\include\socket;..\rt-thread\components\net\sal_socket\impl;..\rt-thread\components\net\sal_socket\include\dfs_net;..\rt-thread\components\net\sal_socket\include\dfs_net\sys_select;..\rt-thread\components\net\sal_socket\include\socket\sys_socket
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab) --keep *.o(VSymTab)
  group Applications
    applications/: main.c
  group Drivers
    drivers/: board.c drv_cache.c drv_mpu.c drv_sdram.c drv_usart.c drv_usbd.c
  group CMSIS
    Libraries/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
    Libraries/CMSIS/Device/ST/STM32F7xx/Source/Templates/arm/: startup_stm32f769xx.s
  group STM32F7xx_HAL_Driver
    Libraries/STM32F7xx_HAL_Driver/: STM32F7xx_HAL_Driver_rvds.lib
  group Kernel
    ../rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group CORTEX-M7
    ../rt-thread/libcpu/arm/cortex-m7/: cpuport.c context_rvds.S
    ../rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    ../rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../rt-thread/components/dfs/filesystems/devfs/: devfs.c
  group DeviceDrivers
    ../rt-thread/components/drivers/misc/: pin.c
    ../rt-thread/components/drivers/serial/: serial.c
    ../rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group rt_usbd
    ../rt-thread/components/drivers/usb/usbdevice/core/: core.c usbdevice.c
    ../rt-thread/components/drivers/usb/usbdevice/class/: rndis.c
  group finsh
    ../rt-thread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group libc
    ../rt-thread/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c time.c
    ../rt-thread/components/libc/compilers/common/: gmtime_r.c
  group lwIP
    ../rt-thread/components/net/lwip-2.0.2/src/arch/: sys_arch.c
    ../rt-thread/components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../rt-thread/components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../rt-thread/components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    ../rt-thread/components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group SAL
    ../rt-thread/components/net/sal_socket/src/: sal_ipaddr.c sal_socket.c
    ../rt-thread/components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    ../rt-thread/components/net/sal_socket/impl/: af_inet_lwip.c
    ../rt-thread/components/net/sal_socket/dfs_net/: dfs_net.c
